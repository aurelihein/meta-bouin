RDEPENDS_${PN}_remove = "connman connman-client "

