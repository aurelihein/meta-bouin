#FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
#SRC_URI += "file://detect-gstreamer-gl.patch"

PACKAGECONFIG = "fetchapi indexeddb mediasource video webaudio webcrypto woff2 remote-inspector"
