FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-avoid_cairo_crash.patch"
#SRC_URI += "file://0002-openmax.patch"
#SRC_URI += "file://0003-gstreamer_holepunch.patch"

#SRC_URI_class-devupstream = "git://git.webkit.org/WebKit.git;branch=wpe-2.28"
#SRCREV_class-devupstream = "6992e8829671a48f9b0d041a5668361d14691dbd"