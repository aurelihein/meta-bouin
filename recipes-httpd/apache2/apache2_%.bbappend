SYSTEMD_AUTO_ENABLE_${PN} = "enable"