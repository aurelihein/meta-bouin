#PACKAGECONFIG = " orc gles2 egl alsa gio-unix-2.0 jpeg ogg pango png theora vorbis zlib wayland opengl "
#PACKAGECONFIG_append = "opengl"
