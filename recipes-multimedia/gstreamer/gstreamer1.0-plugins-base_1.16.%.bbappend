FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-glupload-fix_fallback.patch"
SRC_URI += "file://0002-glupload-fix_segfault.patch"